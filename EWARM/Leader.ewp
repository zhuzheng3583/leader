# IAR project Leader.ewp, settings and files
configuration STM32F4-DISCO (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32F407xx; USE_HAL_DRIVER; USE_STM32F4_DISCO
  ICCARM.CCIncludePath2: ..\src; ..\src\drivers; ..\src\drivers\Drivers\CMSIS\Include; ..\src\drivers\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\src\drivers\Drivers\STM32F4xx_HAL_Driver\Inc; ..\src\drivers\Drivers\BSP\STM32F4-Discovery; ..\src\drivers\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ..\src\drivers\Middlewares\ST\STM32_USB_Device_Library\Class\CustomHID\Inc; ..\src\drivers\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\src\app; ..\src\app\user; ..\src\app\bootloader; ..\src\app\aircraft; ..\src\dsp; ..\src\os
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: USBH_HID.bin
  ILINK.IlinkOutputFile: STM32F4_DISCO.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration BootloaderDebug (ARM, debug)
  as the first configuration, except:
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx; USE_HAL_DRIVER; USE_STM32F4_DISCO; BOOTLOADER
  OBJCOPY.OOCOutputFile: bootloader_debug.bin
  ILINK.IlinkOutputFile: bootloader_debug.out
  ILINK.IlinkIcfFile: bootloader_stm32f407xx_flash.icf
configuration AircraftDebug (ARM, debug)
  as the first configuration, except:
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx; USE_HAL_DRIVER; USE_STM32F4_DISCO; AIRCRAFT
  OBJCOPY.OOCOutputFile: aircraft_debug.bin
  ILINK.IlinkOutputFile: aircraft_debug.out
  ILINK.IlinkIcfFile: aircraft_stm32f407xx_flash.icf
  group (top)
    ../src/: leader.cpp leader.h leader_misc.h leader_type.h
  group app
    ../src/app/: leader_system.cpp leader_system.h main.cpp
  group app/aircraft
    ../src/app/aircraft/: aircraft.cpp aircraft.h
  group app/bootloader
    ../src/app/bootloader/: bootloader.cpp bootloader.h iap.cpp iap.h
  group app/user
    ../src/app/user/: demo_main.c demo_main.h ffconf.h startup_stm32f407xx.s stm32f4xx_hal_conf.h stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c usbd_conf.c usbd_conf.h usbd_customhid_if.c usbd_customhid_if.h usbd_desc.c usbd_desc.h
  group drivers
    ../src/drivers/: core.cpp core.h device.cpp device.h dma.cpp dma.h flash.cpp flash.h gpio.cpp gpio.h i2c.cpp i2c.h interrupt.cpp interrupt.h pwm.cpp pwm.h sensorhub.cpp sensorhub.h sensorhub_type.h sensors.h spi.cpp spi.h timer.cpp timer.h uart.cpp uart.h usb_dev.cpp usb_dev.h
  group drivers/Drivers/BSP
    ../src/drivers/Drivers/BSP/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery.h stm32f4_discovery_accelerometer.c stm32f4_discovery_accelerometer.h
  group drivers/Drivers/Components
    ../src/drivers/Drivers/BSP/Components/lis302dl/: lis302dl.c lis302dl.h
    ../src/drivers/Drivers/BSP/Components/lis3dsh/: lis3dsh.c lis3dsh.h
  group drivers/Drivers/STM32F4xx_HAL_Driver
    ../src/drivers/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../src/drivers/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
    ../src/drivers/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cec.h stm32f4xx_hal_conf_template.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.h
  group drivers/Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID
    ../src/drivers/Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
    ../src/drivers/Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc/: usbd_customhid.h
  group drivers/Middlewares/ST/STM32_USB_Device_Library/Class/HID
    ../src/drivers/Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
    ../src/drivers/Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc/: usbd_hid.h
  group drivers/Middlewares/ST/STM32_USB_Device_Library/Core
    ../src/drivers/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../src/drivers/Middlewares/ST/STM32_USB_Device_Library/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
